# Keil uVision project New626.uvproj, settings and files
target New626 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STMR2000 +hex
  AfterMake: fromelf --bin --output ..\out\STMR2000.bin ..\out\STMR2000.axf -z
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL, USE_STM3210C_EVAL
  c include: ..\inc;..\lwip-1.3.1\src\include\ipv4;..\lwip-1.3.1\src\include\lwip;..\lwip-1.3.1\src\include\netif;..\Libraries\STM32_ETH_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\Core\CM3;..\lwip-1.3.1\src\include;..\lwip-1.3.1\port
  memory RVCT4: ROM 0x8003000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CM3
    ../Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
    ../Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_cl.s
  group User
    ../usr/: main.c netconf.c stm32f10x_it.c stm32f107.c IIC.c Local_232_module.c UDP_module.c common.c ParamItem.c WG.c Local_485_module.c RFIDModule.c R2000.c RTC_DS1302.c stm32flash.c TCP_module.c
  group LWIP
    ../lwip-1.3.1/port/: ethernetif.c
    ../lwip-1.3.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../lwip-1.3.1/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../lwip-1.3.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../lwip-1.3.1/src/netif/: etharp.c
  group STM32_ETH_Driver
    ../Libraries/STM32_ETH_Driver/src/: stm32_eth.c
  group STM32F10x_StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
